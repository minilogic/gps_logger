# IAR project GPS_Logger.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5510 MSP430F5510
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEPRECATED
  ICC430.newCCIncludePaths: ../src; ../src/usb_config; ../src/driverlib/msp430f5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5510.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../src/: gps.c gps.h hal.c hal.h main.c main.h print.c print.h system_pre_init.c
  group driverlib/msp430f55xx_6xx
    ../src/driverlib/MSP430F5xx_6xx/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flashctl.c flashctl.h gpio.c gpio.h ldopwr.c ldopwr.h mpy32.c mpy32.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h wdt_a.c wdt_a.h
  group driverlib/msp430f55xx_6xx/deprecated/ccs
    ../src/driverlib/MSP430F5xx_6xx/deprecated/CCS/: msp430f5xx_6xxgeneric.h
  group driverlib/msp430f55xx_6xx/deprecated/iar
    ../src/driverlib/MSP430F5xx_6xx/deprecated/IAR/: msp430f5xx_6xxgeneric.h
  group driverlib/msp430f55xx_6xx/inc
    ../src/driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h version.h
  group lis3dh
    ../src/lis3dh/: lis3dh_driver.c lis3dh_driver.h msp430_swi2c_master.c msp430_swi2c_master.h
  group usb_api
    ../src/usb_api/: msp430USB.ld
  group usb_api/usb_cdc_api
    ../src/usb_api/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group usb_api/usb_common
    ../src/usb_api/USB_Common/: defMSP430USB.h device.h types.h usb.c usb.h usbdma.c UsbIsr.h
  group usb_api/usb_hid_api
    ../src/usb_api/USB_HID_API/: UsbHid.c UsbHid.h UsbHidReq.c UsbHidReq.h
  group usb_api/usb_msc_api
    ../src/usb_api/USB_MSC_API/: UsbMsc.h UsbMscReq.c UsbMscReq.h UsbMscScsi.c UsbMscScsi.h UsbMscStateMachine.c UsbMscStateMachine.h
  group usb_api/usb_phdc_api
    ../src/usb_api/USB_PHDC_API/: UsbPHDC.c UsbPHDC.h
  group usb_app
    ../src/usb_app/: msc.c msc.h usbEventHandling.c
  group usb_app/fatfs
    ../src/usb_app/FatFs/: diskio.h ff.c ff.h ffconf.h HAL_SDCard.c HAL_SDCard.h mmc.c mmc.h
  group usb_config
    ../src/usb_config/: descriptors.c descriptors.h UsbIsr.c
